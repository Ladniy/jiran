# Repository Ladniy/jiran

File README.md:

# Jiran

This work is licensed under a
[Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International License][cc-by-nc-sa].

[![CC BY-NC-SA 4.0][cc-by-nc-sa-image]][cc-by-nc-sa]

[cc-by-nc-sa]: http://creativecommons.org/licenses/by-nc-sa/4.0/
[cc-by-nc-sa-image]: https://licensebuttons.net/l/by-nc-sa/4.0/88x31.png
[cc-by-nc-sa-shield]: https://img.shields.io/badge/License-CC%20BY--NC--SA%204.0-lightgrey.svg

Jiran is a 6x4 matrix ergo keyboard with additional 3 thumb and 1 pinky keys.

Based on the [Jian](https://github.com/KGOH/Jian-Info) keyboard.

* __Author:__ [t.me/ladniys](https://t.me/ladniys) [u/Ladniy](https://reddit.com/u/Ladniy)
* __Layout:__ [keyboard-layout-editor.com](http://www.keyboard-layout-editor.com/#/gists/0547cd126f61f8c3f76b0a9952901da4)
* __Hardware Availability:__ [Free to use](https://github.com/Ladniy/jiran/releases/tag/v1.0)
* __Firmware:__ [QMK](https://github.com/qmk/qmk_firmware)
* __Building guide:__ [Wiki](https://github.com/Ladniy/jiran/wiki)

Check out [wiki-page](https://github.com/Ladniy/jiran/wiki) for more information.

## KiCad design jiran-cherry/jiran-cherry.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28: 1N4148; Diode_Hybrid_SOD-123
G1, G2: logo-jiran-cherry
HC1, HC2: CoverHole; Hole_Cover_M2
HM1, HM2, HM3, HM4, HM5: CaseHole; Hole_Mount_M4
J1: TRRS; TRSS_DUAL_THT
JP1, JP2, JP3, JP4: Jumper; Jumper_SMD
R29, R30: 4.7K; Resistor_Hybrid_1205
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28: SW_Push; Switch_Mx_Hotswap_1u
SW29: SW_Push; Switch_Reset_THT
U1: ProMicro; ProMicro_Dual

Connections:
/LED: U1.13 (B6/10)
/RST: SW29.1, U1.22 (RST)
/col0: SW1.2, SW7.2, SW13.2, SW19.2, SW25.2, U1.1 (TX0/D3)
/col1: SW2.2, SW8.2, SW14.2, SW20.2, U1.2 (RX1/D2)
/col2: SW3.2, SW9.2, SW15.2, SW21.2, U1.7 (4/D4)
/col3: SW4.2, SW10.2, SW16.2, SW22.2, SW26.2, U1.8 (5/C6)
/col4: SW5.2, SW11.2, SW17.2, SW23.2, SW27.2, U1.9 (6/D7)
/col5: SW6.2, SW12.2, SW18.2, SW24.2, SW28.2, U1.10 (7/E6)
/rowA: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.11 (8/B4)
/rowB: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.12 (9/B5)
/rowC: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.20 (F4/A3)
/rowD: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.19 (F5/A2)
/rowE: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), U1.18 (F6/A1)
GND: J1.B, SW29.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: J1.A, JP1.1 (A), JP2.1 (A)
unnamed: J1.D, JP3.1 (A), JP4.1 (A)
SCL: JP2.2 (B), JP4.2 (B), R30.1, U1.6 (3/D0/SCL)
SDA: JP1.2 (B), JP3.2 (B), R29.2, U1.5 (2/D1/SDA)
VCC: J1.C, R29.1, R30.2, U1.21 (VCC)

Board: 2 copper layers, 152.3 x 104.7 mm, 74 parts (3 on the bottom side), 46 nets.

## Commit log

2020-02-12 Add old files
2020-02-12 Remove old footprint
2020-02-12 Add new footprints
2020-02-12 Update footprint
2020-02-12 Remove reference from PCB
2020-02-12 Move dot for resistor
2020-02-13 Add one more mount hole
2020-02-13 Update footprints list
2020-02-13 Decrease hole size
2020-02-13 Remove case silkscreen
2020-02-13 Remove outline zone
2020-02-14 Create cutout for pinky key
2020-02-14 Update dsn file for route
2020-02-14 Route and fill all zones
2020-02-16 Unfill all zones
2020-02-20 Remove lock leds
2020-02-20 Add 4 pin for nrfmicro
2020-02-20 Add JST pin for battery
2020-02-20 edit silkscreen
2020-02-20 Create footprint for JST connector
2020-02-20 Add pin for JST at eeschema
2020-02-20 Increase hole size
2020-02-22 Remove I2C resistors
2020-02-24 Remove battery pin
2020-02-24 Remove JST connector from scheme
2020-02-25 Add label for SCL
2020-02-25 Add 4.7k resistor for I2C
2020-02-25 Add jumpers for TRRS jack
2020-02-25 Add value for resistors
2020-02-25 Add value for diodes
2020-02-26 Create footprint for jumper
2020-02-26 Add footprints for resistors and jumpers
2020-02-26 Placed resistors and jumpers
2020-02-26 Draw new logo
2020-02-26 Add logo
2020-02-26 Route tracks
2020-02-26 Fill all zones
2020-02-26 Remove old design files
2020-02-26 Add new design files
2020-02-26 Move sign text]
2020-02-26 Update silkscreen at PCB
2020-02-26 Remove old gerbers file
2020-02-26 Create gerber file for new silkscreen
2020-02-26 Move sign text
2020-02-26 Remove gerbers file with new silkscreen
2020-02-26 Create archive with new silkscreen gerber
2020-02-26 Create archive with old silkscreen gerber
2020-02-26 Summ update
2020-02-26 Small fix
2020-02-26 Create PCB and gerber files for FR-4 plate
2020-02-26 Create PCB and gerber files for FR-4 underplate
2020-02-26 Create interactive BOM file
2020-02-28 Create PCB and gerber for cover
2020-02-28 Move pin
2020-03-06 Create files for FR-4 cover
2020-03-06 Create gerber files for FR-4 cover
2020-03-06 Create zip archive with gerber files
2020-03-06 Create gerber files for FR-4 plate
2020-03-06 Some fix
2020-03-08 Remove unused files
2020-03-08 Add silk at PCB
2020-03-08 Add source files for cover silkscreen
2020-03-08 Create gerbers files for cover
2020-03-08 Create archive for gerber files
2020-03-08 Update PCB
2020-03-08 Create gerbers files for plate
2020-03-08 Add new footprint for cutouts
2020-03-08 Update hole positions
2020-03-08 Create gerber files for underplate PCB
2020-03-08 Some update
2020-03-08 Create cutout footprint for FR-4 plate
2020-03-08 Create silkscreen for FR-4 cover
2020-03-08 Update readme file
    Copy and update text from old repo
2020-03-08 Change SMD package
2020-03-12 Fix PCB and gerber files for FR-4 cover
2020-03-12 Create and modify catalog with no pinky case files
2020-03-12 Create and modify catalog with pinky case files
2020-03-12 Remove old files
2020-03-12 Rename new version
2020-03-12 Add more extension for case files
2020-03-21 remove BOM table
2020-03-21 lost dot
2020-03-21 add wiki link
2020-04-02 create other catalog for both version
2020-04-02 move footrints catalog
2020-04-02 create footprints for smd components
2020-04-02 Some fixe
2020-04-02 add new logo silkscreen
2020-04-02 add gerbers file
2020-04-07 Remove old gerber files for plate
2020-04-07 Update footprints
2020-04-07 Plot gerber files
2020-04-13 Route file
2020-04-13 Increase jumper size
2020-04-13 Remove old gerber files
2020-04-13 Plot new gerber files
2020-05-30 Increase distance between pads
2020-05-30 Decrease distance between switch hole and right side
2020-05-31 Remove RGB leds
2020-05-31 Uhfill all zones
2020-05-31 Remove autosave file
2020-05-31 Remove tracks from PCb
2020-05-31 Generate new NET file
2020-05-31 Remove RGB leds footprints
2020-05-31 Add logos
2020-05-31 Export new DSN file
2020-05-31 Create new zip archive with gerbers files
2020-08-01 Rename of all files
2020-08-01 One more rename
2020-08-01 Remove Case folder
2020-08-01 Remove Used_Footprints.pretty
2020-08-01 Change link to qmk firmware
2020-09-17 Remove breakoff future
2020-09-17 Increase hole diametr
2020-09-17 Decrease hole diametr and rename footprint
2020-09-17 Replace some footprint
2020-09-18 Regenerate new dsn file
2020-09-18 Add tracks
2020-09-18 Create ses file for routing
2020-09-18 KiCad project update
2020-09-18 Cache file update
2020-09-18 Bak file update
2020-09-18 Cache and rules file updat
2020-09-18 Remove case files for 44 keys version
2020-09-18 Decrease hole diametr
2020-09-18 Add holes for mount
2020-11-02 Remove old logos
2020-11-02 Create new logotype
2020-11-02 Remove old logo footprints
2020-11-02 Create footprint for new logo
2020-11-02 Add logo as symbol
2020-11-02 Create symbols lib with logo for schematic
2020-11-02 Assign logo symbols with logo footprints
2020-11-02 Remove one hole mount (HM3)
2020-11-02 Remove all tracks
2020-11-02 Update dsn and ses file for freerouting
2020-11-02 Kicad files update
2020-11-02 Plot new gerber file
2020-11-02 Rename files
2020-11-02 Update iBom file
2020-11-02 Rename and delete some pcb files
2020-11-02 Create new logo
2020-11-02 Rename footprint
2020-11-02 Remove LED block
2020-11-02 Update logo symbol
2020-11-02 Update logo, change switch footprints, move diode footprints
2020-11-02 Fix gerber
2020-11-02 Update KiCad files
2020-11-02 Create symbol for hotswap version
2020-11-03 Remove bak file
2020-11-03 Update KiCad cache files
2020-11-03 Create jiran-cherry version
2020-11-03 Update logo for cherry version
2020-11-03 Create jiran-cherry symbol for schematic
2020-11-03 Create logo footprint for jiran-cherry version
2020-11-03 Update symbol logo
2020-11-03 Create new switch footrpint
2020-11-03 Update switch frame
2020-11-03 Assign PCB footprints
2020-11-03 Update logos on pcb
2020-11-03 Change switch footprints
2020-11-03 Add 2 additional pins
2020-11-03 Update switch footprints
2020-11-03 iBom update
2020-11-03 Update sym table, fp cache and other
2020-11-03 Rename underplate folder
2020-11-03 Remove mount hole
2020-11-03 Refill zones
2020-11-03 Change screw holes
2020-11-03 Remove via hole
2020-11-03 Move files in other folder
2020-11-03 Update .dxf file
2020-11-03 Update other files format
2020-11-03 Change preview image
2020-11-03 Change image preview
2020-11-03 Rename gerber fiels
2020-11-03 Create archive with case files
2021-03-15 cache update
2022-02-17 Change license
2022-04-27 Fix license term
